PR_append = "-arago0"

# PSPREL and UVER are used by arago-source-ipk.conf
UVER = "2012.04.01"
PSPREL = "03.22.00.02.sdk"
