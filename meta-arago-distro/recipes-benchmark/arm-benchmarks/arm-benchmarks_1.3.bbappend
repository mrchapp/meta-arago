PR_append = "-arago0"

SRCIPK_SRC_DIR = "${WORKDIR}/git/${PLATFORM_ARCH}"
